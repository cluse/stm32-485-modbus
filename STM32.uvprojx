# Keil uVision project STM32.uvprojx, settings and files
target STM32_USART1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\user;.\Hardware\usart;.\user\CAN;.\Hardware\led;.\Hardware\RS485;.\Hardware\key
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_cl.s
  group User
    ./user/: main.c stm32f10x_it.c pbdata.c bsp.c
  group Hardware
    ./Hardware/led/: led.c
    ./Hardware/usart/: usart.c
    ./Hardware/RS485/: 485.c
    ./Hardware/key/: key.c
  group StdPeriph_Drive
    ./FWlib/SRC/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_flash.c
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
